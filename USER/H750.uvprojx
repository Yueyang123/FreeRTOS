# Keil uVision project H750.uvprojx, settings and files
target H750 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H750 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H750xx,USE_USB_FS
  c include: ..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\LED;..\SYSTEM\sys;..\HARDWARE\TIM;..\HARDWARE\KEY;..\HARDWARE\LTDC;..\HARDWARE\MPU;..\HARDWARE\ADC;..\USMART;..\HARDWARE\TOUCH;..\HARDWARE\RTC;..\MALLOC;..\HARDWARE\W25Q64;..\HARDWARE\SD;..\FatFs;..\USB\STM32_USB_Device_Library\Core\Inc;..\USB\USB_HAL;..\USB\USB_APP;..\FreeRTOS\include;..\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/TIM/: TIM.c
    ../HARDWARE/MPU/: MPU.c
    ../HARDWARE/LTDC/: LTDC.c LTDC_BSP.c
    ../HARDWARE/RTC/: RTC.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/TOUCH/: TOUCH.c
    ../HARDWARE/W25Q64/: W25Q64.c SPI.c BSPQSPI.c
    ../HARDWARE/SD/: sdmmc_sdcard.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c startup_stm32h750xx.s
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FatFs/: diskio.c ff.c ffsystem.c ffunicode.c exfuns.c fattester.c
  group USB
    ../USB/USB_HAL/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
    ../USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_storage.c
    ../USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
